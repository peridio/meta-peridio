BBCLASSEXTEND =+ "native nativesdk"

PV = "1.12.0"
SRCREV = "3dd1798815c206a3c05e8cfbd51de99b2f1dd930"
