require peridiod.inc

PV = "3.0.0-rc.5"

SRCREV = "a71a541917b61a1497f328961b73633250f7bcf1"
SRCBRANCH = "main"
