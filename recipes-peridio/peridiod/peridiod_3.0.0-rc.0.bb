require peridiod.inc

PV = "3.0.0-rc.0"

SRCREV = "90d1de9b99c51ec1b26d4dc3f72d6247ac2712c5"
SRCBRANCH = "rel-v3.0.0-rc.0"
