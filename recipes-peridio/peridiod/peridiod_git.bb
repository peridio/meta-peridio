require peridiod.inc

PV = "2.3.1"

SRCREV = "b257b5400ae8c7129d301896fffaad6f15662ef4"
SRCBRANCH = "remote-console-getty"
