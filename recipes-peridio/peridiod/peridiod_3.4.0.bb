require peridiod.inc

PV = "3.4.0"

SRCREV = "2b4e83c1eb1d4d917a87816af7d4d320701a642f"
SRCBRANCH = "main"
