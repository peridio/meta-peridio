require peridiod.inc

PV = "3.0.0-rc.7"

SRCREV = "fad94022ad2010c6dccebb7595d414c6cd28c3c0"
SRCBRANCH = "main"
