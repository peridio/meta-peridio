require peridiod.inc

PV = "3.2.0"

SRCREV = "cc9a3ded1c79f55ffa0dae906f87fd8410d48990"
SRCBRANCH = "main"
