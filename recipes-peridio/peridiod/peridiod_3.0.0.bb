require peridiod.inc

PV = "3.0.0"

SRCREV = "239668545de1f9ef550e100ec39feb52c5e66742"
SRCBRANCH = "main"
