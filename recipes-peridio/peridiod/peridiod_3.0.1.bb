require peridiod.inc

PV = "3.0.1"

SRCREV = "508e1ac2fa6ca9ebe64bdde00b64197a3305c4e1"
SRCBRANCH = "main"
