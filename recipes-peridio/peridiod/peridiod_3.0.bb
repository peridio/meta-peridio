require peridiod.inc

PV = "3.0.0"

SRCREV = "3a35049d9d330831815712334a9f2cd111c581a2"
SRCBRANCH = "rel-v3.0.0"
