require peridiod.inc

PV = "3.0.0-rc.6"

SRCREV = "cf395b2907a557dde1b6e0bfe347b088d45e796e"
SRCBRANCH = "main"
