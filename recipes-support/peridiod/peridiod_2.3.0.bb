require peridiod.inc

PV = "2.3.0"

SRCREV = "e34018ffdd03a98101ef4d5c6f1c731618a02b63"
SRCBRANCH = "main"
